# Keil uVision project stream.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") CLOCK(12000000) ESEL ELITTLE
  output: stream +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\stream_src;..\..\stream_al
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group demo
    ../../stream_demo/: main.c
  group stream_src
    ../../stream_src/: stream_io.c stream_main.c stream_scheduler.c stream_services.c
  group AL
    ../../stream_al/: platform_al.c platform_computer.c
  group nodes
    ../../stream_nodes/: stream_nodes.c
    ../../stream_nodes/arm/mixer/: arm_stream_mixer.c
    ../../stream_nodes/arm/script/: arm_script.c
software components: CMSIS:CORE 5.6.0, Device:Definition 1.2.0, Device:Startup 2.1.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0
