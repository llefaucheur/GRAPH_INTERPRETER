# Keil uVision project Blinky.uvprojx, settings and files
target LPCXpresso55S69 (6190000::V6.19::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SDK_DEBUGCONSOLE_UART
  c include: ..\..\stream_src; ..\..\stream_libraries\CMSIS-DSP;  ..\..\stream_libraries\CMSIS-DSP\include
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\RTE\Device\LPC55S69JBD100_cm33_core0\LPC55S69_cm33_core0_flash.scf
  link misc: --diag_suppress=L6314
  group App
    ./: Blinky.c
    ../../stream_al/platform_LPC55S69-DK/: main_LPC55S69SDK.c
  group Board
    ./: main.c main.h
  group MCUXpresso
    ./: LPCXpresso55S69.mex
  group Documentation
    ./: README.md
  group graph_src
    ../../stream_src/: stream_graph_interpreter.c stream_io.c stream_scheduler.c stream_services.c
  group graph_al
    ../../stream_al/: platform_al.c
    ../../stream_al/platform_LPC55S69-DK/: platform_LPC55S69SDK.c
  group graph_nodes
    ../../stream_nodes/arm/: stream_nodes.c
    ../../stream_nodes/arm/script/: arm_script_process.c arm_script.c
    ../../stream_nodes/arm/detector/: arm_stream_detector_process.c arm_stream_detector.c
    ../../stream_nodes/arm/filter/: arm_stream_filter.c
  group CMSIS-DSP
    ../../stream_libraries/CMSIS-DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_init_q15.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, CMSIS Driver:VIO:Board 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:LPC55S69_system 1.0.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:dma 2.4.2, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:i2c 2.1.0, Device:SDK Drivers:iocon 2.1.2, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:spi 2.2.1, Device:SDK Drivers:usart 2.4.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
