# Keil uVision project Blinky.uvprojx, settings and files
target STM32C0116-DK (6190000::V6.19::ARMCLANG)
  device: STM32C011F6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\stream_src; ..\..\stream_libraries\CMSIS-DSP;  ..\..\stream_libraries\CMSIS-DSP\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\stm32c011.sct
  link misc: --any_placement=first_fit
  group App
    ./RTE/Device/STM32C011F6Ux/STCubeGenerated/Src/: main.c
    ./: Blinky.c
    ../../stream_al/platform_STM32C0116-DK/: main_STM32C0116DK.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32C011F6Ux/STCubeGenerated/Inc/: stm32c0xx_it.h
    ./RTE/Device/STM32C011F6Ux/STCubeGenerated/Src/: stm32c0xx_it.c main.c
  group STM32CubeMX
    ./RTE/Device/STM32C011F6Ux/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
  group graph_al
    ../../stream_al/: platform_al.c
    ../../stream_al/platform_STM32C0116-DK/: platform_STM32C0116DK.c
  group graph_src
    ../../stream_src/: stream_graph_interpreter.c stream_io.c stream_scheduler.c stream_services.c
  group CMSIS-DSP
    ../../stream_libraries/CMSIS-DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_init_q15.c
  group graph_nodes
    ../../stream_nodes/arm/: stream_nodes.c
    ../../stream_nodes/arm/filter/: arm_stream_filter.c
    ../../stream_nodes/arm/detector/: arm_stream_detector.c arm_stream_detector_process.c
    ../../stream_nodes/arm/script/: arm_script.c arm_script_process.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Board Support:Drivers:Basic I/O 1.0.0, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:ADC 1.0.0, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.0, Device:STM32Cube HAL:DMA 1.0.0, Device:STM32Cube HAL:EXTI 1.0.0, Device:STM32Cube HAL:Flash 1.0.0, Device:STM32Cube HAL:GPIO 1.0.0, Device:STM32Cube HAL:PWR 1.0.0, Device:STM32Cube HAL:RCC 1.0.0, Device:STM32Cube HAL:SPI 1.0.0, Device:STM32Cube HAL:UART 1.0.0, Device:Startup 1.0.0
