# Keil uVision project GraphInterpreter.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: EFM32GG11B820F2048GL120 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32GG11B_DFP.4.2.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GraphInterpreter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\..\..\stream_platform;..\..\..\stream_nodes;..\..\..\stream_src
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source Group 1
    ../../../stream_src/: stream_const.h stream_extern.h stream_graph_interpreter.c stream_io.c stream_scheduler.c stream_types.h
    ../: main.c main_call_computer.c platform_computer.c platform_computer_io_services.c platform_services.c
    ../stream_libraries/CMSIS-DSP/Source/FilteringFunctions/: Computer_arm_biquad_cascade_df1_fast_q15.c Computer_arm_biquad_cascade_df1_init_q15.c
    ../../: platform.h platform_computer.h
    ../../../stream_nodes/arm/amplifier/: arm_stream_amplifier.c
    ../../../stream_nodes/arm/analysis/: arm_stream_analysis.c
    ../../../stream_nodes/arm/demodulator/: arm_stream_demodulator.c
    ../../../stream_nodes/arm/filter/: arm_stream_filter.c
    ../../../stream_nodes/arm/filter2D/: arm_stream_filter2D.c
    ../../../stream_nodes/arm/format_converter/: arm_stream_format_converter.c arm_stream_format_converter_process.c
    ../../../stream_nodes/arm/mixer/: arm_stream_mixer.c arm_stream_mixer_process.c
    ../../../stream_nodes/arm/modulator/: arm_stream_modulator.c arm_stream_modulator_process.c
    ../../../stream_nodes/arm/qos/: arm_stream_qos.c arm_stream_qos_process.c
    ../../../stream_nodes/arm/rescaler/: arm_stream_rescaler.c arm_stream_rescaler_process.c
    ../../../stream_nodes/arm/router/: arm_stream_router.c arm_stream_router_process.c
    ../../../stream_nodes/arm/script/: arm_stream_script.c arm_stream_script_process.c
    ../../../stream_nodes/arm/split/: arm_stream_split.c
    ../../../stream_nodes/bitbank/JPEGENC/: bitbank_JPEGENC.c
    ../../../stream_nodes/elm-lang/TJpgDec/: TjpgDec.c
    ../../../stream_nodes/signal-processingFR/compressor/: sigp_stream_compressor.c sigp_stream_compressor_imadpcm.c sigp_stream_compressor_process.c
    ../../../stream_nodes/signal-processingFR/converter/: sigp_stream_converter.c sigp_stream_converter_coefs.c sigp_stream_converter_process.c
    ../../../stream_nodes/signal-processingFR/decompressor/: sigp_stream_decompressor.c sigp_stream_decompressor_imadpcm.c
    ../../../stream_nodes/signal-processingFR/detector/: sigp_stream_detector.c sigp_stream_detector_process.c
    ../../../stream_nodes/signal-processingFR/detector2D/: sigp_stream_detector2D.c sigp_stream_detector2D_process.c
    ../../../stream_nodes/signal-processingFR/resampler/: sigp_stream_resampler.c sigp_stream_resampler_process.c
software components: CMSIS:CORE 6.0.0
