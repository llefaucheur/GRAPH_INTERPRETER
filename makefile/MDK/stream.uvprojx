# Keil uVision project stream.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stream
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\stream_src;..\..\stream_al
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group demo
    ../../stream_demo/: main.c stream_demo.c
  group stream_src
    ../../stream_src/: stream_io.c stream_main.c stream_scheduler.c stream_services.c stream_ptr_int.c
  group AL
    ../../stream_al/: platform_al.c platform_io.c
  group nodes
    ../../stream_nodes/: stream_nodes.c
    ../../stream_nodes/arm/dsp_convert/: arm_format_converter.c
    ../../stream_nodes/arm/audio_codec/: arm_compress.c arm_decompress.c
    ../../stream_nodes/arm/audio_codec/audio_codec_imadpcm/: arm_code_imadpcm.c
    ../../stream_nodes/arm/dsp_amp/: arm_stream_amplitude.c
    ../../stream_nodes/arm/dsp_filter/: arm_filter.c
    ../../stream_nodes/arm/dsp_src/: arm_rate_converter.c
    ../../stream_nodes/arm/gate/: arm_gating.c
    ../../stream_nodes/arm/merge/: arm_stream_merge.c
    ../../stream_nodes/arm/mixer/: arm_stream_mixer.c
    ../../stream_nodes/arm/route/: arm_stream_route.c
    ../../stream_nodes/arm/split/: arm_stream_split.c
    ../../stream_nodes/arm/vad/: arm_tiny_vad.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
